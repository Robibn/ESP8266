# Repository Robibn/ESP8266

File README.md:

# ESP8266
A ESP8266 board with a sd-card and led´s

I have not been able to test this design,so please doublecheck yourself.

## KiCad design ESP8266_board/esp breakout.kicad_pcb

Parts:
C1: C_sd; C_1206_3216Metric
C2: C_esp; C_1206_3216Metric
C3, C4: C_reg; C_1206_3216Metric
C5: CP; C_Axial_L12.0mm_D6.5mm_P15.00mm_Horizontal
D1, D2, D3, D4, D5, D6, D13, D14: LED; LED_1206_3216Metric
J1: Micro_SD_Card; microSD_HC_Wuerth_693072010801
J2: Conn_01x06; PinSocket_1x06_P2.54mm_Horizontal
J3: PWR; PinSocket_1x06_P2.54mm_Horizontal
J4: SER; PinSocket_1x04_P2.54mm_Horizontal
J5: I2C; PinSocket_1x04_P2.54mm_Horizontal
J6: USB_B_Micro; USB_Micro-B_Amphenol_10103594-0001LF_Horizontal
J7: batt; PinSocket_1x04_P2.54mm_Vertical
Q1: Q_NPN_BEC; SOT-23
R1: R_rst; R_1206_3216Metric
R2, R3, R4, R5, R6, R7, R8, R9, R10: R; R_1206_3216Metric
SW1: SW_Push; SW_SPST_EVPBF
U1: ESP-12E
U2: lm3940; SOT-223
U4: FT230XS; SSOP-16_3.9x4.9mm_P0.635mm

Connections:
+3V3: C1.1, C2.2, C4.1, C5.1, J1.4 (VDD), J3.5, J3.6, J4.1, J5.1, R1.1, R2.2, R3.1, R5.1, U1.3 (EN), U1.8 (VCC), U2.3
+5V: C3.2, J3.1, J6.1 (VBUS), J7.1, Q1.3 (C), U2.1, U4.12 (VCC)
GND: C1.2, C2.1, C3.1, C4.2, C5.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), J1.6 (VSS), J1.9 (SHIELD), J3.2, J3.3, J3.4, J4.3, J5.3, J6.5 (GND), J6.6 (Shield), J7.2, R4.2, SW1.2, U1.15 (GND), U2.2, U2.4, U4.5 (GND), U4.6 (~CTS), U4.13 (GND)
unnamed: D1.2 (A), R5.2
unnamed: D2.2 (A), R10.2
unnamed: D3.2 (A), R7.2
unnamed: D4.2 (A), R8.2
unnamed: D5.2 (A), R9.2
unnamed: D6.2 (A), R6.2
unnamed: D13.1 (K), U4.14 (CBUS1)
unnamed: D13.2 (A), R2.1
unnamed: D14.1 (K), U4.7 (CBUS2)
unnamed: D14.2 (A), R3.2
unnamed: Q1.2 (E), R6.1, R7.1, R8.1, R9.1, R10.1
unnamed: U4.3 (VCCIO), U4.10 (3V3OUT)
adc: J2.3, U1.2 (ADC)
d+: J6.3 (D+), U4.8 (USBDP)
d-: J6.2 (D-), U4.9 (USBDM)
io16: R1.2, SW1.1, U1.1 (~RST), U1.4 (GPIO16), U4.11 (~RESET), U4.15 (CBUS0)
io_0: J2.1, U1.18 (GPIO0), U4.16 (CBUS3)
io_1: J4.2, U1.22 (GPIO1/TXD), U4.4 (RXD)
io_2: J2.2, Q1.1 (B), U1.17 (GPIO2)
io_3: J4.4, U1.21 (GPIO3/RXD), U4.1 (TXD)
io_4: J5.2, J7.4, U1.19 (GPIO4)
io_5: J5.4, J7.3, U1.20 (GPIO5)
sd_clk: J1.5 (CLK), J2.6, U1.5 (GPIO14)
sd_cs: J1.2 (DAT3/CD), R4.1, U1.16 (GPIO15)
sd_miso: J1.7 (DAT0), J2.4, U1.6 (GPIO12)
sd_mosi: J1.3 (CMD), J2.5, U1.7 (GPIO13)

Board: 2 copper layers, 50.0 x 60.0 mm, 35 parts (0 on the bottom side), 29 nets.
